# Keil uVision project DapProgrammer.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DapProgrammer
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F1
  c include: ./src;./libopencm3/include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c
    ./src/: target.c
  group libopencm3
    ./libopencm3/lib/stm32/f1/: gpio.c rcc.c flash.c
    ./libopencm3/lib/cm3/: nvic.c assert.c
    ./libopencm3/lib/stm32/common/: gpio_common_all.c rcc_common_all.c flash_common_f01.c st_usbfs_core.c
    ./src/: usb_setup.c
    ./libopencm3/lib/stm32/: st_usbfs_v1.c
    ./libopencm3/lib/usb/: usb.c usb_standard.c usb_control.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
